ORG 0H
CALL MAIN
HERE: SJMP HERE
ORG 100H
MAIN:
MOV 30H,#4
LOOP_MAIN:
MOV P1,#0F0H
CALL DELAY_NS
MOV P1,#00H
CALL DELAY_NS
LJMP LOOP_MAIN
RET
DELAY_NS:
MOV A,#31
MOV B,30H
MUL AB
MOV R3,A
LOOP_2: 
DJNZ R3,DELAY
RET
DELAY:
MOV R1,#0FFH
MOV R2,#0FFH
MOV TMOD,#00000001B
MOV A,R1
XRL A,#0FFH
MOV R1,A
MOV A,R2
XRL A,#0FFH
MOV R2,A
MOV A,#1
ADD A,R1
MOV R1,A
CLR A
RRC A
ADD A,R2
MOV R2,A
MOV TL0,R1
MOV TH0,R2
SETB TR0
LOOP_1: JNB TF0,LOOP_1
CLR TR0
CLR TF0
LJMP LOOP_2
END